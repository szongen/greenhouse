# Keil uVision project greenhouse.uvprojx, settings and files
target greenhouse (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: greenhouse +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP/Inc;../BSP/Inc;../OneNET/device/inc;../OneNET/MQTT;../OneNET/onenet/inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../BSP/Src/: BSP.c BSP_Debug.c BSP_MultiTimer.c BSP_delay.c BSP_temp_hum.c BSP_display.c BSP_oled.c BSP_ADC_DMA.c BSP_multi_button.c BSP_LED.c
  group APP
    ../APP/Src/: APP_LED.c APP_DHT11.c APP_ADC.c APP_KEY.c APP_OLED.c APP_NET.c APP_Alarm.c APP_Program.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group API
    ../BSP/Src/: API_S_SystemClock.c API_U_SystemClock.c
  group OneNET
    ../OneNET/device/src/: esp8266.c
    ../OneNET/MQTT/: MqttKit.c
    ../OneNET/onenet/src/: onenet.c
software components: CMSIS:CORE 4.3.0
